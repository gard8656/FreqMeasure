# Keil uVision project Panel.uvprojx, settings and files
target Panel (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F429VITx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.13.0
  cpu: IRAM(0x20000000,0x30000) IRAM2(0x10000000,0x10000) IROM(0x08000000,0x200000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: PanelDDS +hex
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32F429xx,PANEL
  c misc: --cpp --diag_suppress=1165
  c include: .\src;.\src\libs\HAL;.\src\Hardware;..\libs\common;..\common\libs\STM32Cube_F4\Drivers\CMSIS\Include;..\common\libs\STM32Cube_F4\Drivers\CMSIS\Device\ST\STM32F4xx\Include;..\common\libs\STM32Cube_F4\Drivers\STM32F4xx_HAL_Driver\Inc;.\src\libs;..\common
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  scatter file: .\Panel.sct
  group HAL
    ../common/libs/STM32Cube_F4/Drivers/STM32F4xx_HAL_Driver/Inc/: stm32f4xx_hal.h stm32f4xx_hal_cortex.h stm32f4xx_hal_gpio.h stm32f4xx_hal_ltdc.h stm32f4xx_hal_rcc.h stm32f4xx_hal_rcc_ex.h
    ../common/libs/STM32Cube_F4/Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal.c stm32f4xx_hal_cortex.c stm32f4xx_hal_gpio.c stm32f4xx_hal_ltdc.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c
  group libs/CMSIS
    ./src/libs/CMSIS/: startup_stm32f429xx.s system_stm32f4xx.c
  group libs/HAL
    ./src/libs/HAL/: stm32f4xx_hal_conf.h stm32f4xx_hal_msp.c
  group src
    ./src/: main.cpp defines.h Device.cpp Device.h
  group Display
    ./src/Display/: Display.cpp Display.h Painter.cpp Painter.h
  group Hardware
    ./src/Hardware/: stm32f4xx_it.c stm32f4xx_it.h HAL.cpp HAL.h
  group Keyboard
    ./src/Keyboard/: Keyboard.cpp Keyboard.h
  group Menu
    ./src/Menu/: Menu.cpp Menu.h MenuItems.cpp MenuItems.h
